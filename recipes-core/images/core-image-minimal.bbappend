IMAGE_INSTALL:append = "\
   cosign \
"
